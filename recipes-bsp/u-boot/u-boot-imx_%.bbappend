SRCBRANCH = "imx95-navq-lf-6.18.y-Q2"
UBOOT_SRC = "git://git@github.com/NXP-Robotics/uboot-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCREV = "576e4183cbf51fdb6d483a0a07da341568ef51a1"
